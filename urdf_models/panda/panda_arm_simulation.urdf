Commit message: draft for que1-d; change mass of link7 to 1.0kg

File: urdf_models/panda/panda_arm_simulation.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: mass 3.0 -> 1.0
